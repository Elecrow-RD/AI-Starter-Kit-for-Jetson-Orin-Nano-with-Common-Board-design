# Repository Elecrow-RD/AI-Starter-Kit-for-Jetson-Orin-Nano-with-Common-Board-design

## EAGLE design Eagle_SCH&PCB/AI_Starter_Kit_for_Jetson_Nano_V1.0.brd

Parts:
C1: 22nF; C0603
C2, C3, C5, C6, C9, C10, C11, C12, C13, C14, C17, C46, C47, C48, C137, C140, C153, C161, C204, C205: 22uF; C0805
C4, C7, C43, C82, C124, C150, C151, C154, C155, C156, C157, C158, C159, C160, C162, C163, C164, C165, C190, C191, C203, C208: 1uF; C0603
C8, C123, C192: 22pF; C0603
C83, C84, C85, C184, C185, C186, C187, C188, C189: 100nF; C0603
C90, C91: 100nF; C0402
C93: 33pF; C0402
C152: 10uF; C0805
C201, C202, C206, C207: 220pF; C0603
C248: NC/1uF; C0603
D502: SS54,SMA; 214AB
FB1: FB 220R/MH2012HM221-T; L0805
FB2, FB7, FB8: FB 220R; L0805
FB3, FB4, FB5: 0R/0805/2A; L0805
FPC1: FPC_24PIN_0.5_4.3_1
FPC4: NV116WHM; 30P*0.5MM
FPC10: FPC_22PIN_0.5_4.3_1
FPC11: FPC_15P_1.0; FPC_P1.0MM_15P_SMD
J11: CONN_20X2; 2X20
J15: CONN_04; 1X04
J214, J215: 1X02L
L1: 10UH 3A; L773
L2: 3.3uH 3A; L0420
L3: 22uH 3A; L773
LED3, LED4, LED5: RED; DISCRETE_LED-0603
M1, M2, M3, M4: M2
P7, P8, P9, P11, P12, P14, P15, P16, P18, P19, P20, P21, P22, P23, P24, P48, P49, P50, P51, P52, P53, P54, P58, P64, P65, P67, P68, P71, P72, P85, P86, P87, P88, P89, P90, P91, P92, P93, P94, P95, P96, P97, P98, P99, P100, P102, P117: PADPAD-1.0MM; PAD-1.0MM
Q1: S9013; SOT23-3
Q2: AO3401; PMOS_SOT23
Q4, Q101, Q102: S9013; SOT23@1
Q112: NC/S9013; SOT23@1
R2: 150K; R0603
R3: 33K; R0603
R4, R8, R10, R38, R41, R155, R178, R180, R181, R183, R187, R233, R234, R236, R502: 10K; R0603
R5, R9, R11: 100K; R0603
R6: 49.9K; R0603
R7: 59K; R0603
R12, R179, R182: 1K; R0603
R20, R40, R103, R186, R188, R232, R235, R332: NC; R0603
R37, R126, R184, R213: 0R; R0603
R49, R50, R51, R52, R53, R54, R57, R58, R66, R90, R99: 0R; R0402
R61, R91: 1M; R0402
R62, R69, R88: NC/4.7K; R0402
R67, R68, R95: 100R; R0402
R70, R97: 100K; R0402
R92, R93: 1K; R0402
R96: 4.7K; R0402
R98: 10K; R0402
R114: 12K; R0603
R153, R218: 4.7K; R0603
R154: 2K; R0603
R185: 5.1M; R0603
R209, R210: 47K; R0603
R216: NC/100K; R0603
R217: NC/4.7K; R0603
R501: 200K; R0603
R514: 240K; R0603
U1: MT2496-SOT23-6; SOT23-6L
U11: MT3520B; IC_SOT23-5
U17: W25Q80; LORA_RA-08H_DEV_SELF_SOIC-8-208MIL
U119: RTD2556; IC_RTD2556_LQFP156_14X20
U120: PAM8602E_SSOP24; SSOP24
U501: MT3608; MT3608-SOT23-6
X101: X32251431818MSB4SI; CRYSTAL-3.2-2.5

Connections:
1V1_LCD: C11.2, C12.2, FB3.1, L2.2, P20.P$1, R6.2, R154.2
3V3_AU: R126.2, U119.150 (150_AUDIO_VDD33), U119.156 (156_AUDIO_VDD33)
3V3_LCD: C2.2, C3.2, C4.2, C8.1, FB4.1, FB5.2, L1.2, P19.P$1, R2.2, R40.1, R90.1, R153.2, R218.2
3V3_LCD_S: C190.2, C191.2, FB5.1, FPC4.P$12 (12_VCC_3V), FPC4.P$13 (13_VCC_3V), P65.P$1, R178.2, R181.2, R183.2
5V_BL_DC: C13.2, C14.2, L3.1, Q2.3 (D), R514.2, U501.5
12V_LCD_BL: C47.1, C48.1, C137.1, C140.1, D502.2 (-), FPC4.P$26 (26_VCC_BL), FPC4.P$27 (27_VCC_BL), FPC4.P$28 (28_VCC_BL), FPC4.P$29 (29_VCC_BL), P18.P$1, R155.2, R501.1
+5V_SYS: C5.2, C6.2, C7.2, C9.2, C10.2, J11.2, J11.4, J15.4, P9.P$1, P117.P$1, Q2.2 (S), R10.2, R20.1, R37.2, U1.5 (VIN), U11.4 (VIN); also elsewhere on the board
ADJBACKLITE: R179.2, R180.2, U119.54 (54_PWM5)
AU_L: C43.2, U119.154 (154_AUDIO_SOUTL_0)
AU_R: C82.2, U119.155 (155_AUDIO_SOUTR_0)
A_GND: R184.1, U119.149 (149_AGND)
BL_DC_EN: R12.2, U119.63 (63_PWM2_IR_IN)
CAM0_I2C_SCL: FPC10.20, FPC11.P$13 (13)
CAM0_I2C_SDA: FPC10.21, FPC11.P$14 (14)
CAM0_MCLK: FPC10.18, FPC11.P$12 (12)
CAM0_PWDN_LS: FPC10.17, FPC11.P$11 (11)
CE: R233.2, R235.2, U17.1 (/CS), U119.60 (60_SPI_CEB)
CLK: U17.6 (CLK), U119.57 (57_SPI_CLK)
CSI1_CLK_N: FPC10.8, FPC11.P$8 (8)
CSI1_CLK_P: FPC10.9, FPC11.P$9 (9)
CSI1_D0_N: FPC10.2, FPC11.P$2 (2)
CSI1_D0_P: FPC10.3, FPC11.P$3 (3)
CSI1_D1_N: FPC10.5, FPC11.P$5 (5)
CSI1_D1_P: FPC10.6, FPC11.P$6 (6)
CSI_GND: FPC10.1, FPC10.4, FPC10.7, FPC10.10, FPC11.P$1 (1), FPC11.P$4 (4), FPC11.P$7 (7), FPC11.P$10 (10)
D0/ID_I2C_SDA: J11.27
D1/ID_I2C_SCL: J11.28
D2/I2C1_SDA: J11.3; also elsewhere on the board
D3/I2C1_SCL: J11.5; also elsewhere on the board
D4: J11.7; also elsewhere on the board
D5/CAM_AF_EN*: J11.29
D6: J11.31; also elsewhere on the board
D7/SPI0_CS1: J11.26
D8/SPI0_CS0: J11.24; also elsewhere on the board
D9/SPI0_MISO: J11.21; also elsewhere on the board
D10/SPI0_MOSI: J11.19; also elsewhere on the board
D11/SPI0_SCK: J11.23; also elsewhere on the board
D12/PWM: J11.32; also elsewhere on the board
D13/PWM: J11.33; also elsewhere on the board
D14/UART1_TXD: J11.8; also elsewhere on the board
D15/UART1_RXD: J11.10; also elsewhere on the board
D16/UART1_CTS: J11.36; also elsewhere on the board
D17/UART1_RTS: J11.11; also elsewhere on the board
D18/I2S0_SCLK: J11.12; also elsewhere on the board
D19/I2S0_LRCK: J11.35
D20/I2S0_SDIN: J11.38; also elsewhere on the board
D21/I2S0_SDOUT: J11.40
D22/LCD_TE*: J11.15
D23/SPI1_CS1: J11.16; also elsewhere on the board
D24/SPI1_CS0: J11.18
D25/SPI1_MISO: J11.22; also elsewhere on the board
D26/SPI1_MOSI: J11.37; also elsewhere on the board
D27/SPI1_SCK: J11.13; also elsewhere on the board
DCCSCL_VGA: P16.P$1, U119.131 (131_DDCSCL_VGA)
DCCSDA_VGA: P15.P$1, U119.132 (132_DDCSDA_VGA)
DDR_SDRAM: R103.1, U119.1 (1_DDR_SDRAM), U119.53 (53_PVCC), U119.56 (56_PVCC), U119.142 (142_PVCC)
DPTX_AUX_N_2: C189.1, U119.52 (52_EDPTX_AUX_N_1)
DPTX_AUX_N_2_1: C189.2, FPC4.P$10 (10_AUX_N), P53.P$1
DPTX_AUX_P_2: C188.1, U119.51 (51_EDPTX_AUX_P_1)
DPTX_AUX_P_2_1: C188.2, FPC4.P$9 (9_AUX_P), P52.P$1
DP_3V3: FPC1.1, P100.P$1
DP_AUXN: C90.2, FPC1.4, P96.P$1, R62.2, R91.1, R92.1
DP_AUXP: C91.2, FPC1.5, P95.P$1, R61.2, R88.1, R93.1
DP_CABLE_DET: FPC1.3, P97.P$1, R67.2
DP_CEC: FPC1.6, P94.P$1, R66.2
DP_HPD: FPC1.2, P99.P$1, R68.1, R69.2, R70.1
DP_MODE: FPC1.7, P93.P$1, R95.2
DP_VCC: R61.1, R62.1, R69.1, R90.2, R98.1
FB_S: R501.2, R502.1, U501.3
FLASH_WP: R232.1, R234.2, U17.3 (/WP(IO2)), U119.61 (61_FLASH_WP)
GND: C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C17.1, C46.1, C47.2, C48.2, C83.2, C84.2, C85.2, C123.1, C124.2, C137.2, C140.2, C150.1, C151.1, C152.1, C153.1, C154.1, C155.1, C156.1, C157.1, C158.1, C159.1, C160.1, C161.1, C162.1, C163.1, C164.1, C165.1, C190.1, C191.1, C192.1, C201.2, C202.2, C203.2, C204.2, C205.2, C206.2, C207.2, C208.1, C248.2, FPC1.8, FPC1.11, FPC1.14, FPC1.17, FPC1.20, FPC1.24, FPC4.P$2 (2_GND), FPC4.P$5 (5_GND), FPC4.P$8 (8_GND), FPC4.P$11 (11_GND), FPC4.P$15 (15_GND), FPC4.P$16 (16_GND), FPC4.P$18 (18_GND_BL), FPC4.P$19 (19_GND_BL), FPC4.P$20 (20_GND_BL), FPC4.P$21 (21_GND_BL), J11.6, J11.9, J11.14, J11.20, J11.25, J11.30, J11.34, J11.39, J15.1, J214.3, J214.4, J215.3, J215.4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; also elsewhere on the board
GPIO_PA_MUTE: R213.1, U119.66 (66_PWM5_GPIO)
HOLD(DQ3): R236.1, U17.7 (/HOLD/RESET(IO3))
JS_3V3: J11.1, J11.17, P11.P$1, R4.1, R8.1; also elsewhere on the board
LANE_0N: FPC1.18, P86.P$1, R57.2
LANE_0P: FPC1.19, P85.P$1, R58.2
LANE_1N: FPC1.15, P88.P$1, R53.2
LANE_1P: FPC1.16, P87.P$1, R54.2
LANE_2N: FPC1.12, P90.P$1, R51.2
LANE_2P: FPC1.13, P89.P$1, R52.2
LANE_3N: FPC1.9, P92.P$1, R49.2
LANE_3P: FPC1.10, P91.P$1, R50.2
LED_EN: FPC4.P$22 (22_EN), P58.P$1, Q102.3 (C), R181.1
LED_PWM: FPC4.P$23 (23_PWM), P64.P$1, Q101.3 (C), R178.1
LINE_EAR_DET: R40.2, R41.1, U120.15 (15_LINE/EAR)
MIC_USB_D+: FPC1.23, P72.P$1; also elsewhere on the board
MIC_USB_D-: FPC1.22, P71.P$1; also elsewhere on the board
unnamed: C1.2, L1.1, U1.6 (SW)
unnamed: C1.1, U1.1 (BS)
unnamed: C8.2, R2.1, R3.2, U1.3 (FB)
unnamed: R4.2, R5.2, U1.4 (EN)
unnamed: R8.2, R9.2, U11.1 (EN)
unnamed: Q1.1 (B), R11.2, R12.1
unnamed: Q1.3 (C), Q2.1 (G), R10.1
unnamed: Q102.1 (B), R182.1
unnamed: R209.1, U120.8 (8_INL), U120.9 (9_EINL)
unnamed: R210.1, U120.16 (16_EINR), U120.17 (17_INR)
unnamed: C83.1, C84.1, C85.1, C204.1, C205.1, R37.1, U120.5 (5_VDDL), U120.7 (7_VDD), U120.10 (10_VDC), U120.20 (20_VDDR)
unnamed: C203.1, U120.14 (14_VREF)
unnamed: FB1.2, U120.1 (1_OUTL+)
unnamed: FB2.2, U120.4 (4_OUTL-)
unnamed: FB7.2, U120.24 (24_OUTR+)
unnamed: FB8.2, U120.21 (21_OUTR-)
unnamed: C82.1, R210.2
unnamed: C43.1, R209.2
unnamed: Q112.1 (B), R217.2, R332.1
unnamed: Q101.1 (B), R179.1
unnamed: Q112.3 (C), R38.2, R218.1
unnamed: C124.1, U119.153 (153_AUDIO_REF)
unnamed: LED3.+, R153.1
unnamed: L2.1, U11.3 (SW)
unnamed: LED4.+, R154.1
unnamed: LED5.+, R155.1
unnamed: R6.1, R7.2, U11.5 (FB)
unnamed: Q4.3 (C), R95.1
unnamed: Q4.1 (B), R96.2, R97.2
unnamed: D502.1 (+), L3.2, U501.1
unnamed: R514.1, U501.4
OUTL+: C201.1, FB7.1, J215.2, P22.P$1
OUTL-: C202.1, FB8.1, J215.1, P21.P$1
OUTR+: C206.1, FB1.1, J214.1, P23.P$1
OUTR-: C207.1, FB2.1, J214.2, P24.P$1
PA_VOLUME_CINTROL: C248.1, R38.1, U120.11 (11_VOLUME)
R_DP_AUXN: C90.1, C93.1, U119.138 (138_DDCSDA_1)
R_DP_AUXP: C91.1, C93.2, U119.137 (137_DDCSCL_1)
R_DP_CABLE_DET: R67.1, R98.2, U119.119 (119_GPIO)
R_DP_CEC: R66.1, R99.2, U119.136 (136_GPIO)
R_DP_HPD: R68.2, U119.74 (74_GPIO_WS)
R_DP_MODE: R96.1, U119.135 (135_GPIO)
R_DP_SINK_ASS_N: R92.2, U119.71 (71_GPIO_SDO)
R_DP_SINK_ASS_P: R93.2, U119.72 (72_GPIO_MCK)
R_HDMI_DDC_SCL: J15.3, P8.P$1, U119.79 (79_GPIO)
R_HDMI_DDC_SDA: J15.2, P7.P$1, U119.80 (80_GPIO)
R_HDMI_HPD: U119.84 (84_GPIO_HDMI_HPD)
R_HDMI_MHL_DET: U119.65 (65_PWM_IN_GPIO)
R_HDMI_TXC_N: U119.86 (86_RXCN_3)
R_HDMI_TXC_P: U119.87 (87_RXCP_3)
R_HDMI_TXD0_N: U119.88 (88_RXON_3)
R_HDMI_TXD0_P: U119.89 (89_RXOP_3)
R_HDMI_TXD1_N: U119.91 (91_RX1N_3)
R_HDMI_TXD1_P: U119.92 (92_RX1P_3)
R_HDMI_TXD2_N: U119.93 (93_RX2N_3)
R_HDMI_TXD2_P: U119.94 (94_RX2P_3)
R_LANE_0N: R57.1, U119.98 (98_RX0P_1)
R_LANE_0P: R58.1, U119.97 (97_RX0N_1)
R_LANE_1N: R53.1, U119.100 (100_RX1P_1)
R_LANE_1P: R54.1, U119.99 (99_RX1N_1)
R_LANE_2N: R51.1, U119.102 (102_RX2P_1)
R_LANE_2P: R52.1, U119.101 (101_RX2N_1)
R_LANE_3N: R49.1, U119.104 (104_RXCN_1)
R_LANE_3P: R50.1, U119.103 (103_RXCP_1)
SDIN: U17.5 (DI(IO0)), U119.58 (58_SPI_SI)
SDOUT: U17.2 (DO(IO1)), U119.59 (59_SPI_SO)
SHDN_MUTE: R213.2, R216.2, U120.6 (6_/MUTE), U120.19 (19_/SHDN)
TMDS_REXT: R114.1, R186.1, U119.83 (83_TMDS_REXT)
TX2_HPD: FPC4.P$17 (17_HPD), P54.P$1, R187.2
TX2_HPD_2: R187.1, R188.1, U119.50 (50_EDPTX_HPD)
TXA3N: C187.1, U119.17 (17_TXA3N)
TXA3N_1: C187.2, FPC4.P$7 (7_L0_P), P51.P$1
TXA3P: C186.1, U119.16 (16_TXA3P)
TXA3P_1: C186.2, FPC4.P$6 (6_L0_N), P50.P$1
USB_5V: FPC1.21, P68.P$1, R20.2
VCC1V1_LCD: C17.2, C150.2, C151.2, C152.2, C153.2, C154.2, C155.2, C156.2, C157.2, FB3.2, U119.2 (2_VCCK_OFF), U119.9 (9_EDPTX_VDD11), U119.15 (15_EDPTX_VDD1_1), U119.45 (45_VCCK_OFF2), U119.55 (55_VCCK_OFF3), U119.62 (62_VCCK_ON), U119.95 (95_GDI_11V), U119.105 (105_GDI_11V3), U119.117 (117_GDI_11V4), U119.134 (134_V11S_ON_1), U119.146 (146_V11S_ON_3)
VCC3V3_LCD: C46.2, C158.2, C159.2, C160.2, C161.2, C162.2, C163.2, C164.2, C165.2, C208.2, FB4.2, R103.2, R126.1, R186.2, R188.2, R232.2, R233.1, R236.2, U17.8 (VCC), U119.12 (12_EDPTX_VDD33), U119.34 (34_PVCC), U119.46 (46_PVCC2), U119.75 (75_PVCC3), U119.85 (85_RX_33V), U119.96 (96_RX_33V_1), U119.120 (120_ADC_V33), U119.139 (139_PVCC), U119.145 (145_PVCC_2)
VDD_3V3_CAM: FPC10.22, FPC11.P$15 (15)
VOL_CINTROL_0: R217.1, U119.68 (68_I2C_SDA)
VTX_TX1N: C185.1, U119.14 (14_VTX_TX1N)
VTX_TX1N_1: C185.2, FPC4.P$4 (4_L1_P), P49.P$1
VTX_TX1P: C184.1, U119.13 (13_VTX_TX1P)
VTX_TX1P_1: C184.2, FPC4.P$3 (3_L1_N), P48.P$1
W74XM_DO: R182.2, R183.1, U119.64 (64_PWM_OUT_GPIO)
XI: C192.2, R185.1, U119.140 (140_XI), X101.3 (C2)
XO: C123.2, R185.2, U119.141 (141_XO), X101.1 (C1)

Notes on the sheet:
LCD_Drive
LCD_Interface
Audio_Interface
FPC_DP&USB_Interface
LCD_POWER
Jetson DP&USB_Input
Vref=0.6V
Orin nano才有CEC和MODE，nano是不接这两个
RTD2556程序下载接口
核心板端
摄像头端
Jetson 40pin Interface
Camera Interface

Notices in the files:
parts and their libraries:
SparkFun-Connectors: Licensing: Creative Commons ShareAlike 4.0 International - https://creativecommons.org/licenses/by-sa/4.0
